# Keil uVision project rainbow.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: rainbow +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source Group 1
    ./: STARTUP.A51
    ../src/: main.c uart.c qst_sw_i2c.c qmaX981.c iic.c
